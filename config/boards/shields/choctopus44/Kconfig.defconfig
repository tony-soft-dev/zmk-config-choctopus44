## config/boards/shields/choctopus44/Kconfig.defconfig
```kconfig
if SHIELD_CHOCTOPUS44

config ZMK_KEYBOARD_NAME
    default "choctopus44"

endif
```
